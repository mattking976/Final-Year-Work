# Keil uVision project C3.uvprojx, settings and files
target C3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: C3
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;  C:/Users/acesak3/STM32Cube/Repository/STM32Cube_FW_F4_V1.18.0/Drivers/STM32F4xx_HAL_Driver/Inc;  C:/Users/acesak3/STM32Cube/Repository/STM32Cube_FW_F4_V1.18.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  C:/Users/acesak3/STM32Cube/Repository/STM32Cube_FW_F4_V1.18.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include;  C:/Users/acesak3/STM32Cube/Repository/STM32Cube_FW_F4_V1.18.0/Drivers/CMSIS/Include;C:/Users/acesak3/STM32Cube/Repository/STM32Cube_FW_F4_V1.18.0/Middlewares/ST/STM32_USB_Host_Library/Core/Inc;C:/Users/acesak3/STM32Cube/Repository/STM32Cube_FW_F4_V1.18.0/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;C:/Users/acesak3/STM32Cube/Repository/STM32Cube_FW_F4_V1.18.0/Middlewares/Third_Party/FatFs/src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    C:/Users/acesak3/STM32Cube/Repository/STM32Cube_FW_F4_V1.18.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: stm32f4xx_it.c main.c stm32f4xx_hal_msp.c usb_host.c fatfs.c usbh_diskio.c usbh_platform.c usbh_conf.c
  group Middlewares/FatFs
    C:/Users/acesak3/STM32Cube/Repository/STM32Cube_FW_F4_V1.18.0/Middlewares/Third_Party/FatFs/src/option/: syscall.c
    C:/Users/acesak3/STM32Cube/Repository/STM32Cube_FW_F4_V1.18.0/Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
  group Middlewares/USB_Host_Library
    C:/Users/acesak3/STM32Cube/Repository/STM32Cube_FW_F4_V1.18.0/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_scsi.c usbh_msc_bot.c
    C:/Users/acesak3/STM32Cube/Repository/STM32Cube_FW_F4_V1.18.0/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_pipes.c usbh_ctlreq.c usbh_ioreq.c usbh_core.c
software components: CMSIS:CORE 4.3.0
